FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-device.patch file://serial_dev_bus.cfg"
